# Keil uVision project MB_GPS.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: MB_GPS +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c delay.c delay.h oled.c oled.h OLED_Font.h uart.c uart.h var.h
